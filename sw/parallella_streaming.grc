options:
  parameters:
    generate_options: qt_gui
    id: parallella_streaming
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/stdin
    repeat: 'False'
    type: short
    vlen: '8'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '8'
    type: short
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    color4: cyan
    color5: dark red
    color6: dark blue
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab_widget_0@1
    label1: RIGHT
    label2: TOP
    label3: NC
    label4: REAR
    label5: Scintillator
    label6: NC
    label7: NC
    label8: NC
    nconnections: '8'
    size: '1024'
    srate: samp_rate
    tr_chan: '4'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"Ohradnik"'
    type: float
    ymax: '10000'
    ymin: '-10000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab_widget_0@0 : 0,0,1,1'
    label1: RIGHT
    type: float
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab_widget_0@0 : 0,1,1,1'
    label1: TOP
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab_widget_0@0 : 1,0,1,1'
    label1: REAR
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Frequency
    label1: Time
    num_tabs: '2'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_short_to_float_0_1, '0', qtgui_time_sink_x_0, '4']
- [blocks_short_to_float_0_2, '0', qtgui_time_sink_x_0, '6']
- [blocks_short_to_float_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_short_to_float_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_short_to_float_1_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_short_to_float_1_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_short_to_float_1_1, '0', qtgui_time_sink_x_0, '5']
- [blocks_short_to_float_1_2, '0', qtgui_time_sink_x_0, '7']
- [blocks_vector_to_streams_0, '0', blocks_short_to_float_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_short_to_float_1, '0']
- [blocks_vector_to_streams_0, '2', blocks_short_to_float_0_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_short_to_float_1_0, '0']
- [blocks_vector_to_streams_0, '4', blocks_short_to_float_0_1, '0']
- [blocks_vector_to_streams_0, '5', blocks_short_to_float_1_1, '0']
- [blocks_vector_to_streams_0, '6', blocks_short_to_float_0_2, '0']
- [blocks_vector_to_streams_0, '7', blocks_short_to_float_1_2, '0']

metadata:
  file_format: 1
