options:
  parameters:
    generate_options: qt_gui
    id: parallella_streaming
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/stdin
    repeat: 'False'
    type: short
    vlen: '8'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_1_2
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '8'
    type: short
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    comment: channel 1
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 'tab_widget_0@0 : 0,0,1,1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: 'tab_widget_0@0: 0,1,1,1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: tab_widget_0@0:1,0,1,1
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: fosphor_qt_sink_c_0_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    gui_hint: tab_widget_0@0:1,1,1,1
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: iqbalance_fix_cc_0
  id: iqbalance_fix_cc
  parameters:
    mag: '1'
    phase: '1'
  states: {}
- name: iqbalance_optimize_c_0
  id: iqbalance_optimize_c
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    color5: yellow
    color6: dark blue
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab_widget_0@1
    label1: 1I
    label2: 1Q
    label3: 2I
    label4: 2Q
    label5: 3I
    label6: 3Q
    label7: 4I
    label8: 4Q
    nconnections: '8'
    size: '1024'
    srate: samp_rate
    tr_chan: '7'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '10000'
    ymin: '-10000'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '4'
    type: complex
  states: {}
- name: tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Frequency
    label1: Time
    num_tabs: '2'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_float_to_complex_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', fosphor_qt_sink_c_0_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_waterfall_sink_x_0, '1']
- [blocks_float_to_complex_0_1, '0', iqbalance_fix_cc_0, in]
- [blocks_float_to_complex_0_1, '0', iqbalance_optimize_c_0, in]
- [blocks_float_to_complex_0_2, '0', fosphor_qt_sink_c_0_0_0_0, '0']
- [blocks_float_to_complex_0_2, '0', qtgui_waterfall_sink_x_0, '3']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_short_to_float_0_1, '0', blocks_float_to_complex_0_1, '0']
- [blocks_short_to_float_0_1, '0', qtgui_time_sink_x_0, '4']
- [blocks_short_to_float_0_2, '0', blocks_float_to_complex_0_2, '0']
- [blocks_short_to_float_0_2, '0', qtgui_time_sink_x_0, '6']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_short_to_float_1_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_short_to_float_1_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_short_to_float_1_1, '0', blocks_float_to_complex_0_1, '1']
- [blocks_short_to_float_1_1, '0', qtgui_time_sink_x_0, '5']
- [blocks_short_to_float_1_2, '0', blocks_float_to_complex_0_2, '1']
- [blocks_short_to_float_1_2, '0', qtgui_time_sink_x_0, '7']
- [blocks_vector_to_streams_0, '0', blocks_short_to_float_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_short_to_float_1, '0']
- [blocks_vector_to_streams_0, '2', blocks_short_to_float_0_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_short_to_float_1_0, '0']
- [blocks_vector_to_streams_0, '4', blocks_short_to_float_0_1, '0']
- [blocks_vector_to_streams_0, '5', blocks_short_to_float_1_1, '0']
- [blocks_vector_to_streams_0, '6', blocks_short_to_float_0_2, '0']
- [blocks_vector_to_streams_0, '7', blocks_short_to_float_1_2, '0']
- [iqbalance_fix_cc_0, out, fosphor_qt_sink_c_0_0_0, '0']
- [iqbalance_fix_cc_0, out, qtgui_waterfall_sink_x_0, '2']
- [iqbalance_optimize_c_0, iqbal_corr</name>, iqbalance_fix_cc_0, iqbal_corr]

metadata:
  file_format: 1
